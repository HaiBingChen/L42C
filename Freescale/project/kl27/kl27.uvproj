# Keil uVision project kl27.uvproj, settings and files
target KL27 (ARM-ADS)
  device: MKL27Z64xxx4 Freescale Semiconductor
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: kl27
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL27Z64VLH4, FRDM_KL27Z, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ..\..\application\inc;..\..\platform\CMSIS\Include;..\..\platform\devices;..\..\platform\devices\MKL27Z644\include;..\..\platform\devices\MKL27Z644\startup;..\..\platform\hal\inc;..\..\platform\drivers\inc;..\..\platform\system\inc;..\..\platform\utilities\inc;..\..\platform\system\src\clock\MKL27Z644;..\..\platform\hal\src\sim\MKL27Z644;..\..\board\kl27\inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ..\..\platform\devices\MKL27Z644\linker\arm\MKL27Z64xxx4_flash.scf
  link misc: --remove 
--predefine="-D__stack_size__=0x300" 
--predefine="-D__heap_size__=0x200"
  group utilities
    ../../platform/utilities/src/: fsl_debug_console.c fsl_misc_utilities.c print_scan.c
  group startup
    ../../platform/devices/MKL27Z644/startup/arm/: startup_MKL27Z644.s
    ../../platform/devices/MKL27Z644/startup/: system_MKL27Z644.c
    ../../platform/devices/: startup.c
  group hal
    ../../platform/hal/src/uart/: fsl_uart_hal.c
    ../../platform/system/src/clock/MKL27Z644/: fsl_clock_MKL27Z644.c
    ../../platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../platform/hal/src/mcglite/: fsl_mcglite_hal.c fsl_mcglite_hal_modes.c
    ../../platform/hal/src/sim/MKL27Z644/: fsl_sim_hal_MKL27Z644.c
    ../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../platform/hal/src/tpm/: fsl_tpm_hal.c
    ../../platform/hal/src/gpio/: fsl_gpio_hal.c
  group driver
    ../../platform/drivers/src/tpm/: fsl_tpm_driver.c fsl_tpm_common.c
    ../../platform/drivers/src/gpio/: fsl_gpio_driver.c fsl_gpio_common.c
  group board
    ../../application/src/: hardware_init.c
    ../../board/kl27/src/: board.c pin_mux.c
  group application
    ../../application/src/: main.c smartcard.c
