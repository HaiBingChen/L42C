# Keil uVision project kl17.uvprojx, settings and files
target kl17 (ARM-ADS)
  device: MKL17Z256xxx4 Freescale Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: kl17 +hex
  AfterMake: fromelf --bincombined --output=.\debug\kl17.bin .\debug\kl17.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL17Z256VMP4, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ..\..\application\inc;..\..\platform\CMSIS\Include;..\..\platform\devices;..\..\platform\devices\MKL17Z4\include;..\..\platform\devices\MKL17Z4\startup;..\..\platform\hal\inc;..\..\platform\drivers\inc;..\..\platform\system\inc;..\..\platform\utilities\inc;..\..\platform\system\src\clock\MKL17Z4;..\..\platform\hal\src\sim\MKL17Z4;..\..\board\kl17\inc;..\..\lib;..\..\test\inc;..\..\middleware\inc;..\..\platform\osa\inc;..\..\middleware\src\ui;..\..\middleware\inc;..\..\spi_dma
  asm define: DEBUG, CPU_MKL17Z256VMP4, FREEDOM
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: ..\..\platform\devices\MKL17Z4\linker\arm\MKL17Z256xxx4_flash.scf
  link misc: --remove 
--predefine="-D__stack_size__=0x300" 
--predefine="-D__heap_size__=0x200"
  group utilities
    ../../platform/utilities/src/: fsl_debug_console.c fsl_misc_utilities.c print_scan.c
    ../../application/src/: fsl_delay.c
  group startup
    ../../platform/devices/: startup.c
    ../../platform/devices/MKL17Z4/startup/arm/: startup_MKL17Z4.s
    ../../platform/devices/MKL17Z4/startup/: system_MKL17Z4.c
  group hal
    ../../platform/hal/src/uart/: fsl_uart_hal.c
    ../../platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../platform/hal/src/mcglite/: fsl_mcglite_hal.c fsl_mcglite_hal_modes.c
    ../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../platform/hal/src/tpm/: fsl_tpm_hal.c
    ../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../platform/system/src/clock/MKL17Z4/: fsl_clock_MKL17Z4.c
    ../../platform/hal/src/sim/MKL17Z4/: fsl_sim_hal_MKL17Z4.c
    ../../platform/hal/src/spi/: fsl_spi_hal.c
    ../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../platform/osa/src/: fsl_os_abstraction_bm.c
    ../../platform/system/src/power/: fsl_power_manager.c
    ../../platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../platform/drivers/src/lpuart/: fsl_lpuart_driver.c fsl_lpuart_common.c
  group driver
    ../../platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../platform/drivers/src/spi/: fsl_spi_common.c
    ../../platform/drivers/src/lptmr/: fsl_lptmr_common.c fsl_lptmr_irq.c fsl_lptmr_driver.c
    ../../platform/drivers/src/pit/: fsl_pit_irq.c fsl_pit_common.c fsl_pit_driver.c
    ../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../platform/drivers/src/tpm/: fsl_tpm.c fsl_tpm_common.c fsl_tpm_driver.c
  group middleware
    ../../middleware/src/spi/: spi.c
    ../../middleware/src/timer/: timer.c
    ../../middleware/src/power/: power.c
    ../../middleware/src/booster/: booster.c
    ../../middleware/src/led/: led.c
    ../../middleware/src/ui/: Ui.c
    ../../middleware/src/tpm/: tpm_timer.c
  group board
    ../../application/src/: hardware_init.c
    ../../board/kl17/src/: board.c pin_mux.c
  group application
    ../../application/src/: main.c 7816.c NordicCmdPackage.c
  group lib
    ../../lib/: SCD_HB.lib
  group test
    ../../test/src/7816/: 7816_test.c
    ../../test/src/spi/: spi_test.c
  group spi_dma
    ../../spi_dma/: ExtSpiFlash.c FGPIO.c fsl_clock.c fsl_common.c fsl_dma.c fsl_dmamux.c fsl_gpio.c fsl_lpuart.c fsl_smc.c fsl_spi.c fsl_spi_dma.c fsl_uart.c seeed_lcd.c display_font.c display_ancs.c Ota_LpUart0.c
