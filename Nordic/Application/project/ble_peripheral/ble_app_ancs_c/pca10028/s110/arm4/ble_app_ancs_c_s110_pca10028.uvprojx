# Keil uVision project ble_app_ancs_c_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 BSP_UART_SUPPORT SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0  UI_SUPPORT
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\bsp;..\..\..\..\..\osal;..\..\..\..\..\memory;..\..\..\..\..\mainsys;..\..\..\..\..\ble_profile;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\task;..\..\..\..\..\handler;..\..\..\..\..\DataStore;..\..\..\..\..\DataParser;..\..\..\..\..\Display;..\..\..\..\..\sensor;..\..\..\..\..\flash;..\..\..\..\..\Reminder;..\..\..\..\..\motor;..\..\..\..\..\touch;..\..\..\..\..\protocol;..\..\..\..\..\..\components\ble\ble_services\ble_ccids;..\..\..\..\..\scanner;..\..\..\..\..\advertiser;..\..\..\..\..\Timer;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\config;..\..\..\..\..\update;..\..\..\..\..\..\components\ble\ble_services\ble_media;..\..\..\..\..\hrm;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\toolchain\gcc
  asm define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 BSP_UART_SUPPORT SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x23400
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp_btn_ble.c bsp.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_ancs_c/: ble_ancs_c.c
    ../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
    ../../../../../../components/ble/ble_services/ble_ccids/: ble_ccids.c
    ../../../../../../components/ble/ble_services/ble_media/: ble_media.c
    ../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
    ../../../../../../components/drivers_nrf/spi_master/: spi_master.c
    ../../../../../../components/drivers_nrf/spi_slave/: spi_slave.c
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../../components/libraries/pwm/: app_pwm.c
    ../../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group osal
    ../../../../../osal/: OsalTimer.c Osal.c OsalClock.c OsalMemory.c OsalMessage.c OsalPort.c OsalTaskEvent.c
  group memory
    ../../../../../memory/: mem.c heap_1.c heap_2.c heap_3.c heap_4.c
  group mainsys
    ../../../../../mainsys/: clockdriver.c AppHandler.c Macrodef.h
  group ble_profile
    ../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../../ble_profile/: simpleGATTprofile.c
  group task
    ../../../../../task/: HwTask.c StepTask.c DisplayTask.c SleepTask.c ClockTask.c TouchKeyTask.c BleTask.c heartRateTask.c
  group handler
    ../../../../../handler/: VolumeHandler.c BatteryStatusHandler.c BlueToothHandler.c RingModeHandler.c StandbyHandler.c AlarmHandler.c SleepHandler.c SportHandler.c PhoneHandler.c SmardCardHandler.c DevicesComHandler.c heartRateHandler.c
  group DataStore
    ../../../../../DataStore/: Utils.c UserInfo.c DataStoreInside.c AncsRemove.lib AncsRemove.h
  group DataParser
    ../../../../../DataParser/: HardWareTest.c NeuL18CmdPackage.c BootloaderApp.c circbuf.c BC5CmdPackage.c protocol.c KL17CmdPackage.c AncsCrc.c
  group Display
    ../../../../../Display/: Res.c FontLib.c FontDisplay.c Ui.c lcd.c spim.c pwm.c
  group Reminder
    ../../../../../Reminder/: Reminder.c
  group flash
    ../../../../../flash/: ExtSpiFlash.c
  group sensor
    ../../../../../sensor/: AxisI2c.c lis3dh.c Bma2xx.c ALG_A2_0_14_L42C.lib GR_A_1_0_3_ALG_L42C.lib
  group motor
    ../../../../../motor/: Motor.c
  group touch
    ../../../../../touch/: upper_level_xxx.c IQS263_Handler.c lower_level_xxx.c CypressI2c.c
  group advertiser
    ../../../../../advertiser/: advertiser_beacon.c
  group scanner
    ../../../../../scanner/: scanner_beacon.c scanner_parse.c
  group Timer
    ../../../../../Timer/: Secondstimer.c
  group update
    ../../../../../update/: port_me.c bl_erase_region.c bl_ping.c bl_private.c bl_read_memory.c bl_update.c bl_write_memory.c code2str.c
  group hrm
    ../../../../../hrm/: AS7000_I2c.c usr_ble_hrs.c AS7000.c AS7000_update.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: as above
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
